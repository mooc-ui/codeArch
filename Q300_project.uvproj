# Keil uVision project Q300_project.uvproj, settings and files
target Target 1 (MCS-51)
  device: CH548 WCH
  cpu: IRAM(0-0xFF) XRAM(0-0x3FFF)  IROM(0-0x3FFF) CLOCK(48000000)
  output: CH549EXAM +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\ADC;.\Compare;.\FlashRom;.\GPIO;.\Public;.\PWM;.\SPI;.\Timer;.\TouchKey;.\UART;.\USB;.\Type_C
  group Source Group 1
    ./GPIO/: GPIO.C Main.C
    ./Public/: DEBUG.C
    ./UART/: UART.C
