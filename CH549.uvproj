# Keil uVision project CH549.uvproj, settings and files
target Target 1 (MCS-51)
  device: CH549 WCH
  cpu: IRAM(0-0xFF) XRAM(0-0x3FFF)  IROM(0-0x3FFF) CLOCK(56000000)
  output: CH549EXAM +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\ADC;.\Compare;.\FlashRom;.\GPIO;.\Public;.\PWM;.\SPI;.\Timer;.\TouchKey;.\UART;.\USB;.\Type_C;.\bluetooth
  group Source Group 1
    ./Public/: DEBUG.C
    ./UART/: UART.C Main.C
    ./ADC/: ADC.C
    ./Timer/: Timer.C
    ./GPIO/: GPIO.C
    ./PWM/: PWM.C
    ./bluetooth/: bluetoothCommunication.c
    ./vk1640/: vk1640_led.c lamp_tape.c
    ./FlashRom/: FlashRom.C
  group arch
    ./qsport_arch/: qsportArch.c
